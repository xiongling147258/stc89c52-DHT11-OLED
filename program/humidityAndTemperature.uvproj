# Keil uVision project humidityAndTemperature.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: humidityAndTemperature +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c dht11.c OLED.c OLED.h OLEDFont.h
